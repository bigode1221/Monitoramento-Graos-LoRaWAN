# IAR project LoRaWAN_End_Node_LBM.ewp, settings and files
configuration LoRaWAN_End_Node_LBM (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32WL55xx; NUMBER_OF_STACKS=1; SX126X; ENDNODE
  ICCARM.CCIncludePath2: ../Core/Inc; ../LoRaWAN/App; ../LoRaWAN/Target; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/timer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b; ../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_C; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/service_template; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/relay_service; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/lfu_service; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/store_and_forward; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_api; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_manager; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_hal; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/smtc_secure_element; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_supervisor; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_utilities; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_api; ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WLxx_Nucleo; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ralf/src; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ral/src; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_planner/src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\Conf; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\radio_drivers\sx126x_driver\src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\radio_planner\src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\smtc_ral\src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\smtc_ralf\src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Drivers/STM32WLxx_HAL_Driver/Inc; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/trace/adv_trace; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/misc; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/sequencer; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/timer; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/lpm/tiny_lpm; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_api; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_hal; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_manager; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_api; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_c; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_rx; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_tx; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/smtc_multicast; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/beacon_tx_service; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/lfu_service; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/service_template; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_utilities; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/smtc_secure_element; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/radio_driver; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_planner/src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ral/src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ralf/src; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Drivers/CMSIS/Device/ST/STM32WLxx/Include; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/relay_service; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/store_and_forward; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_supervisor; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/soft_secure_element; C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\Conf; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\radio_drivers\sx126x_driver\src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\radio_planner\src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\smtc_ral\src; ..\..\..\..\..\..\Middlewares\Third_Party\SubGHz_Phy\lorawan\smtc_ralf\src
  OBJCOPY.OOCOutputFile: LoRaWAN_End_Node_LBM.hex
  ILINK.IlinkOutputFile: LoRaWAN_End_Node_LBM.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: adc_if.c usart_if.c main.c gpio.c adc.c dma.c flash_if.c stm32_lpm_if.c sys_app.c sys_debug.c sys_sensors.c timer_if.c rng.c rtc.c subghz.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/LoRaWAN/App
    ../LoRaWAN/App/: app_lorawan.c CayenneLpp.c lora_app.c
  group Application/User/LoRaWAN/Target
    ../LoRaWAN/Target/: radio_board_if.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rng.c stm32wlxx_hal_rng_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_ll_adc.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rng.c stm32wlxx_hal_rng_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Middlewares/LoRaWAN
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_api/: lorawan_api.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_manager/: lorawan_cid_request_management.c lorawan_class_b_management.c lorawan_dwn_ack_management.c lorawan_join_management.c lorawan_send_management.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification/: lorawan_certification.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b/: smtc_beacon_sniff.c smtc_ping_slot.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common/: relay_mac_parser.c relay_real.c wake_on_radio.c wake_on_radio_ral.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_rx/: relay_rx.c relay_rx_mac_parser.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_tx/: relay_tx.c relay_tx_mac_parser.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/smtc_multicast/: smtc_multicast.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src/: region_as_923.c region_au_915.c region_cn_470.c region_cn_470_rp_1_0.c region_eu_868.c region_in_865.c region_kr_920.c region_ru_864.c region_us_915.c region_ww2g4.c smtc_real.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/beacon_tx_service/: lorawan_beacon_tx_service_example.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/lfu_service/: file_upload.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/service_template/: service_template.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_utilities/: circularfs.c fifo_ctrl.c modem_core.c modem_event_utilities.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c smtc_lora_cad_bt.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/relay_service/: lorawan_relay_rx_service.c lorawan_relay_tx_service.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/store_and_forward/: store_and_forward.c store_and_forward_flash.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_supervisor/: modem_supervisor_light.c modem_tx_protocol_manager.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/soft_secure_element/: aes.c cmac.c soft_se.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/LoRaWAN/smtc_modem_core/: smtc_modem.c smtc_modem_test.c
  group Middlewares/LoRaWAN/smtc_modem_core
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/: smtc_modem.c smtc_modem_test.c
  group Middlewares/LoRaWAN/smtc_modem_core/lorawan_api
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_api/: lorawan_api.c
  group Middlewares/LoRaWAN/smtc_modem_core/lorawan_manager
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_manager/: lorawan_cid_request_management.c lorawan_class_b_management.c lorawan_dwn_ack_management.c lorawan_join_management.c lorawan_send_management.c
  group Middlewares/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lorawan_packages/lorawan_certification/: lorawan_certification.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_b/: smtc_beacon_sniff.c smtc_ping_slot.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/common/: relay_mac_parser.c relay_real.c wake_on_radio.c wake_on_radio_ral.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_rx
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_rx/: relay_rx.c relay_rx_mac_parser.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_tx
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/relay/relay_tx/: relay_tx.c relay_tx_mac_parser.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/services
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c smtc_lora_cad_bt.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/services/smtc_multicast
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/services/smtc_multicast/: smtc_multicast.c
  group Middlewares/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/lr1mac/src/smtc_real/src/: region_as_923.c region_au_915.c region_cn_470.c region_cn_470_rp_1_0.c region_eu_868.c region_in_865.c region_kr_920.c region_ru_864.c region_us_915.c region_ww2g4.c smtc_real.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/beacon_tx_service
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/beacon_tx_service/: lorawan_beacon_tx_service_example.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/lfu_service
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/lfu_service/: file_upload.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/relay_service
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/relay_service/: lorawan_relay_rx_service.c lorawan_relay_tx_service.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/service_template
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/service_template/: service_template.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_services/store_and_forward
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_services/store_and_forward/: store_and_forward.c store_and_forward_flash.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_supervisor
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_supervisor/: modem_supervisor_light.c modem_tx_protocol_manager.c
  group Middlewares/LoRaWAN/smtc_modem_core/modem_utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/modem_utilities/: circularfs.c fifo_ctrl.c modem_core.c modem_event_utilities.c
  group Middlewares/LoRaWAN/smtc_modem_core/smtc_modem_crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
  group Middlewares/LoRaWAN/smtc_modem_core/smtc_modem_crypto/soft_secure_element
    ../../../../../../Middlewares/Third_Party/LoRaWAN/smtc_modem_core/smtc_modem_crypto/soft_secure_element/: aes.c cmac.c soft_se.c
  group Middlewares/SubGHz_Phy
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src/: lr_fhss_mac.c sx126x.c sx126x_driver_version.c sx126x_lr_fhss.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_planner/src/: radio_planner.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ral/src/: ral_sx126x.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ralf/src/: ralf_sx126x.c
  group Middlewares/SubGHz_Phy/Conf
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/Conf/: subghz_template.c
  group Middlewares/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_drivers/sx126x_driver/src/: lr_fhss_mac.c sx126x.c sx126x_driver_version.c sx126x_lr_fhss.c
  group Middlewares/SubGHz_Phy/lorawan/radio_planner/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/radio_planner/src/: radio_planner.c
  group Middlewares/SubGHz_Phy/lorawan/smtc_ral/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ral/src/: ral_sx126x.c
  group Middlewares/SubGHz_Phy/lorawan/smtc_ralf/src
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/lorawan/smtc_ralf/src/: ralf_sx126x.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/trace/adv_trace/: stm32_adv_trace.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/sequencer/: stm32_seq.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/timer/: stm32_timer.c
    C:/Users/ryank/STM32Cube/Repository/STM32Cube_FW_WL_V1.5.0/Utilities/lpm/tiny_lpm/: stm32_lpm.c
